Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: 46ec4172-06ee-4490-8b81-5cb4f0c7c011, VersionGUID: 1d50fdcd-4ea5-47cf-a355-10bfb6851a97, NumberOfSaves: 125]
File name: exportacao_2025.ifc
Time: 2026-10-31T19:28:07+00:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.0.32 (ENU) - IFC 25.4.40.0

# IfcProject, 7765328-33-A
LongName: Snowdon Towers; Phase: Construction Documents

# IfcSite, Default
RefLatitude: 40, 1, 20, 538978; RefLongitude: -79, -53, -11, -994970; RefElevation: 0 ft
Pset_SiteCommon - Reference: Project Information
Pset_SpaceCommon - Reference: Project Information; IsExternal: no
Other - Category: Project Information; Client Name: Autodesk; Project Address: 43 Market ST Brownsville, PA 15417; Project Issue Date: 6/1/2023; Project Name: Snowdon Towers; Project Number: 7765328-33-A; Project Status: Construction Documents
Identity Data - Author: Autodesk; Building Name: Snowdon Towers; Organization Name: Brownsville, PA

# IfcBuilding, Snowdon Towers
LongName: Snowdon Towers
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 3
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no; sets with these values: 2
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Autodesk; Project Address: 43 Market ST Brownsville, PA 15417; Project Issue Date: 6/1/2023; Project Name: Snowdon Towers; Project Number: 7765328-33-A; Project Status: Construction Documents
Identity Data - Author: Autodesk; Building Name: Snowdon Towers; Organization Name: Brownsville, PA

# IfcBuildingStorey: Level:Arch_1/4" Head (4)
In: Snowdon Towers
Pset_BuildingStoreyCommon - Reference: Arch_1/4" Head
Pset_SpaceCommon - IsExternal: no; Reference: Arch_1/4" Head
Other - Category: Levels; Family: Level; Family and Type: Level: Arch_1/4" Head; Type: Arch_1/4" Head; Type Id: 27
Dimensions - Computation Height: 0 ft
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 2 Default: yes; Symbol at End 1 Default: no
Identity Data(Type) - Type Name: Arch_1/4" Head
Name | LongName = Name | Elevation (ft) = Constraints, Elevation (ft)
Block 37 - Parapet | Block 37 - Parapet | 47.6667
Block 43 - Parapet | Block 43 - Parapet | 51.1667
Block 39 - Parapet | Block 39 - Parapet | 54.6667
Green Roof Hardscape | Green Roof Hardscape | 59.9167 | Extents - Scope Box: Levels

# IfcBuildingStorey: Level:Arch_1/4" Head (Symbol Both Ends) (14)
In: Snowdon Towers
Pset_BuildingStoreyCommon - Reference: Arch_1/4" Head (Symbol Both Ends)
Pset_SpaceCommon - IsExternal: no; Reference: Arch_1/4" Head (Symbol Both Ends)
Other - Category: Levels; Family: Level; Family and Type: Level: Arch_1/4" Head (Symbol Both Ends); Type: Arch_1/4" Head (Symbol Both Ends); Type Id: 2118242
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Arch_1/4" Head (Symbol Both Ends)
Name | LongName = Name | Elevation (ft) = Constraints, Elevation (ft) | Computation Height (ft) | Scope Box
Parking | Parking | -16.9167 | 0 | Levels
L1 - Block 35 | L1 - Block 35 | -5.91667 | 0 | Levels
L1 - Block 37 | L1 - Block 37 | -3.45833 | 3
L1 - Block 43 | L1 - Block 43 | 0 | 0 | Levels
M1 | M1 | 5.5 | 3 | Levels
L2 | L2 | 8.08333 | 0 | Levels
L3 | L3 | 18.8333 | 0 | Levels
L4 | L4 | 32.1667 | 0 | Levels
L5 | L5 | 45.5 | 0 | Levels
R1 | R1 | 52.6667 | 0 | Levels
R2 | R2 | 58.8333 | 0 | Levels
Parapet | Parapet | 63.5 | 0 | Levels
R3 | R3 | 68.8333 | 0 | Levels
Parapet 2 | Parapet 2 | 70.8333 | 0 | Levels

# IfcBuildingElementProxy: Slab Edge:Bleacher Seating (2)
Type - Other - Category: Floors: Slab Edges; Family Name: Slab Edge
Type - Construction - Profile: PRF_Seat : PRF_Seat
Type - Identity Data - Type Name: Bleacher Seating
Type - Materials and Finishes - Material: Steel, Paint Finish, Dark Gray
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Bleacher Seating
Pset_EnvironmentalImpactIndicators - Reference: Bleacher Seating
Other - Family: Slab Edge; Family and Type: Slab Edge: Bleacher Seating; Type: Bleacher Seating; Type Id: 1066644
Constraints - Horizontal Profile Offset: 0 ft; Vertical Profile Offset: 0 ft
Identity Data - Design Option: 2059970
Phasing - Phase Created: New Construction
Profile - Angle: 0 deg
Name (Slab Edge:Bleacher Seating:...) | In | Length (ft) | Volume (ft3) | Mark
2059997 | Green Roof Hardscape | 18.7437 | 4.8603 | 9
2060021 | R1 | 18.535 | 4.80664 | 1 | Group: Model Group:Bleachers w Middle Stair:2060022

# IfcDistributionPort, Port_1602800_1
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: ELECTRICAL

# IfcGroup: Model Group:Bleachers w Middle Stair, Model Group:Bleachers w Middle Stair:2060022
Other - Category: Model Groups; Family: Model Group; Family and Type: Model Group: Bleachers w Middle Stair; Type: Bleachers w Middle Stair; Type Id: 1066773
Constraints - Origin Level Offset: 0 ft; Reference Level: R1
Identity Data - Design Option: 2059970
Other(Type) - Category: Model Groups; Family Name: Model Group
Identity Data(Type) - Type Name: Bleachers w Middle Stair

# IfcLightFixture: Sconce Light - Uplight:100W - 120V, Sconce Light - Uplight:100W - 120V:1602800
In: L2
Type - Material: <Unnamed>
Type - Other - Category: Lighting Fixtures; Family Name: Sconce Light - Uplight
Type - Constraints - Default Elevation: 0 ft
Type - Dimensions - Light Source Symbol Size: 2 ft; Mounting Height: 6.33333 ft
Type - Electrical - Ballast Number of Poles: 1; Ballast Voltage: 120 V; Lamp: R-30; Load Classification: Lighting - Dwelling Unit
Type - Electrical - Loads - Apparent Power: 100 W
Type - Identity Data - Assembly Code: D5020220; Assembly Description: Lighting - Incandescent; OmniClass Number: 23.80.70.11.14.14; OmniClass Title: Uplights; Type Name: 100W - 120V
Type - Photometrics - Ballast Loss: 1; Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 12 s3*lm/kg/m2; Illuminance: 41.1151 lx; Initial Color Temperature: 2800 K; Lamp Lumen Depreciation: 1; Lamp Tilt Loss: 1; Light Source Definition (family): Point+HemiSpherical; Luminaire Dirt Depreciation: 1; Luminous Flux: 1200 lm; Luminous Intensity: 381.972 cd; Surface Depreciation Loss: 1; Temperature Loss: 1; Total Light Loss Factor: 1; Voltage Loss: 1; Wattage: 100 W
Type - Materials and Finishes - Shade Material: Glass, Frosted
Classification: D5020220 Lighting - Incandescent (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: 100W - 120V; sets with these values: 2
Other - Family: Sconce Light - Uplight; Family and Type: Sconce Light - Uplight: 100W - 120V; Host Id: 748873; Type: 100W - 120V; Type Id: 1602775
Constraints - Elevation from Level: -5 ft; Level: L2
Dimensions - Area: 7.02252 ft2; Volume: 2.2593 ft3
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 311
Phasing - Phase Created: New Construction
